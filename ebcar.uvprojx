# Keil uVision project ebcar.uvprojx, settings and files
target ebcar (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebcar
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,STM32F10X_HD
  c include: Inc;Drivers\STM32F1xx_HAL_Driver\Inc;Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;Drivers\CMSIS\Device\ST\STM32F1xx\Include;Drivers\CMSIS\Include;Middlewares\Third_Party\FreeRTOS\Source\include;Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;MDK-ARM\RTE\_ebcar;.eide\deps;usr\app\inc;usr\dev\inc;usr\bsp\inc
  asm define: USE_HAL_DRIVER,STM32F103xE,STM32F10X_HD
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x20000000 size 0x10000
  group Middlewares/FreeRTOS
    Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/STM32F1xx_HAL_Driver
    Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal.c
  group Drivers/CMSIS
    Src/: system_stm32f1xx.c
  group Application/User
    Src/: freertos.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c
  group Application/User/dev
    usr/dev/src/: mots.c usdev.c
  group Application/User/bsp
    usr/bsp/src/: bsp_delay.c
  group Application/User/app
    usr/app/src/: detctask.c runtask.c
  group Application/MDK-ARM
    MDK-ARM/: startup_stm32f103xe.s
